<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zmq_trx_zmq</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_ip</value></param>
<param><key>value</key><value>'127.0.0.1'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rat_id</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_destination_address</value></param>
<param><key>value</key><value>'tcp://' + destination_ip + ':' + str(rx_destination_port)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_destination_port</value></param>
<param><key>value</key><value>(rat_id * 1000) + rx_destination_suffix</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_destination_suffix</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_source_address</value></param>
<param><key>value</key><value>'tcp://' + source_ip + ':' + str(rx_source_port)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_source_port</value></param>
<param><key>value</key><value>(rat_id * 1000) + rx_source_suffix</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_source_suffix</value></param>
<param><key>value</key><value>501</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_ip</value></param>
<param><key>value</key><value>'127.0.0.1'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_destination_address</value></param>
<param><key>value</key><value>'tcp://' + destination_ip + ':' + str(tx_destination_port)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_destination_port</value></param>
<param><key>value</key><value>(rat_id * 1000) + tx_destination_suffix</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_destination_suffix</value></param>
<param><key>value</key><value>201</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_source_address</value></param>
<param><key>value</key><value>'tcp://' + source_ip + ':' + str(tx_source_port)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_source_port</value></param>
<param><key>value</key><value>(rat_id * 1000) + tx_source_suffix</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_source_suffix</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.06</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>rx_len</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>packet_len</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>tx_source_address</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0_0</value></param>
<param><key>address</key><value>rx_source_address</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>address</key><value>tx_destination_address</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0</value></param>
<param><key>address</key><value>rx_destination_address</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>zeromq_push_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
