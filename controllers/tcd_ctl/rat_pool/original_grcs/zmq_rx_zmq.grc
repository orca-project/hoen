<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zmq_rx_zmq</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>'tcp://' + destination_ip + ':' + str(destination_port)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_ip</value></param>
<param><key>value</key><value>'127.0.0.1'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_port</value></param>
<param><key>value</key><value>(rat_id * 1000) + destination_suffix</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_suffix</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rat_id</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>'tcp://' + source_ip + ':' + str(source_port)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_ip</value></param>
<param><key>value</key><value>'127.0.0.1'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_port</value></param>
<param><key>value</key><value>(rat_id * 1000) + source_suffix</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_suffix</value></param>
<param><key>value</key><value>501</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"len"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>source_address</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>address</key><value>destination_address</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
